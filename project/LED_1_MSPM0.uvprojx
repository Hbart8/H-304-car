# Keil uVision project LED_1_MSPM0.uvprojx, settings and files
target LED_1_MSPM0 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LED_1_MSPM0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../sdk/source/third_party/CMSIS/Core/Include;../sdk/source;..\..\Project;..\app;..\app\OLED;..\app\SYS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../sdk/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group User/sys
    ../app/SYS/: Delay.c Delay.h Serial.c Serial.h AppTick.c AppTick.h Buzzer.c Buzzer.h
  group User/arch
    ../app/ARCH/: app_system.c app_system.h
    ../app/ARCH/config/: app_config.h board_profile.h
    ../app/ARCH/control/: pid.c pid.h motion_control.c motion_control.h
    ../app/ARCH/behavior/: behavior_motion.c behavior_motion.h
    ../app/ARCH/device/: device_center.c device_center.h device_gyro.c device_gyro.h device_track_sensor.c device_track_sensor.h
    ../app/ARCH/task/: task_service.c task_service.h
    ../app/ARCH/scheduler/: app_scheduler.c app_scheduler.h
    ../app/ARCH/interaction/: interaction_service.c interaction_service.h
    ../app/ARCH/hal/: hal_board.c hal_board.h hal_chassis.c hal_chassis.h
  group User/oled
    ../app/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
  group User/menu
    ../app/MENU/: menu.c menu.h menu_app.c menu_app.h menu_port.c menu_port.h
